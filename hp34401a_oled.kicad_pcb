# Repository openscopeproject/HP34401a-OLED-HW

File README.md:

# HP 34401a 6½ digit multimeter OLED display mod

This is repository for hardware part of the mod.

See [firmware repository](https://github.com/openscopeproject/HP34401a-OLED-FW) for more information.

This board was designed in KiCad 5 and uses exclusively standard KiCad libraries.

# Multimeter with OLED display

# PCB render

----

# Schematic

## KiCad design hp34401a_oled.kicad_pcb

Board: 2 copper layers, 30.0 x 33.5 mm, 34 parts (16 on the bottom side), 42 nets.

Parts:
C1, C2: 47uF; CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder
C3, C4, C5, C6, C7: 0.1uF; C_0603_1608Metric
D1: PWR; LED_0805_2012Metric
D2: STATUS; LED_0805_2012Metric
D3: BAT54C; SOT-23
J1: USB_B_Micro; USB_Micro-B_Wuerth_614105150721_Vertical
J2: DISPLAY; PinHeader_2x08_P2.54mm_Vertical
J3: UART; PinHeader_1x04_P2.54mm_Vertical
J4: FP; PinHeader_1x06_P2.54mm_Vertical
J5: DISPLAYPWR; PinHeader_1x01_P2.54mm_Vertical
JP1: BOOT; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: NO DIODE; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
MH1, MH2, MH3, MH4: MountingHole; MountingHole_3.2mm_M3_ISO14580
R1, R7, R8: 100k; R_0805_2012Metric
R2: 1K5; R_0805_2012Metric
R3, R4: 1K; R_0805_2012Metric
R5, R6: 22R; R_0805_2012Metric
RN1: 10K; R_Array_Convex_4x0603
U1: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U2: LM1117-3.3; SOT-223-3_TabPin2
U3: AT24C02; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 8M; Resonator_SMD_muRata_CSTxExxV-3Pin_3.0x1.1mm

Connections:
+3V3: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, D1.2, D2.2, J2.2, J3.4, JP1.3, R1.1, R2.2, U1.9, U1.24, U1.36, U1.48, U2.2, U3.8
+12V: D3.1, J4.2, J5.1, JP2.1
/BOOT0: R7.2, U1.44
/BOOT1: J2.14, R8.2, U1.20
/CS: J2.16, U1.22
/DB0: J2.4, U1.10
/DB1: J2.5, U1.11
/DB2: J2.6, U1.12
/DB3: J2.7, U1.13
/DB4: J2.8, U1.14
/DB5: J2.9, U1.15
/DB6: J2.10, U1.16
/DB7: J2.11, U1.17
/PC13: R4.2, U1.2
/RD: J2.12, U1.18
/Reset: J2.15, U1.21
/SCL: U1.42, U3.6
/SDA: U1.43, U3.5
/SPI_INT: J4.6, RN1.1
/SPI_MISO: J4.4, RN1.3
/SPI_MOSI: J4.3, RN1.4
/SPI_SCK: J4.5, RN1.2
/USART_RX: J3.2, U1.31
/USART_TX: J3.3, U1.30
/USBDN: R6.1, U1.32
/USBDP: R5.1, U1.33
/Vin: C1.1, D3.3, JP2.2, U2.3
/WR: J2.13, U1.19
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, J1.5, J1.6, J2.1, J3.1, J4.1, JP1.1, R3.2, R8.1, U1.8, U1.23, U1.35, U1.47, U2.1, U3.1, U3.2, U3.3, U3.4, U3.7, Y1.2
unnamed: D1.1, R3.1
unnamed: D2.1, R4.1
unnamed: J1.2, R6.2
unnamed: J1.3, R2.1, R5.2
unnamed: JP1.2, R7.1
unnamed: R1.2, U1.7
unnamed: RN1.5, U1.28
unnamed: RN1.6, U1.27
unnamed: RN1.7, U1.26
unnamed: RN1.8, U1.25
unnamed: U1.5, Y1.1
unnamed: U1.6, Y1.3
VBUS: D3.2, J1.1

## Commit log

2018-07-13 First pass on the board
2018-07-13 Remove backup files
2018-07-14 Tweak size, footprints, generate gerber
2018-07-14 Few more tweaks
2018-07-24 Generate bom
2018-08-14 Update bom
2018-08-14 Change headers to virtual
2018-08-14 Add render
2018-08-14 Add license
2018-08-14 Add schematic
2018-08-14 Fix image links
2018-08-27 Update readme with final pic
    update bom
2019-04-05 Small tweaks for KiCad 5.1 compatibility

Notices in the files:
hp34401a_oled.kicad_pcb:
Licensed under CERN Open Hardware Licence v1.2
